#include "sys.h"

/*****************************************************
 * 迪文屏节奏大师二次开发
 * 页面 5 / 8 为游戏界面
 * 页面 6 / 9 为成功界面
 * 页面 7 / 10 为失败界面
 *****************************************************/

#define PAGE_GAME_5            5
#define PAGE_SUCCESS_6         6
#define PAGE_FAIL_7            7
#define PAGE_GAME_8            8
#define PAGE_SUCCESS_9         9
#define PAGE_FAIL_10           10

#define MUSIC_LEN              34000U     // 游戏总时长(ms)

#define GAME_STATUS_VAR        0x2000U    // 游戏状态：0 空闲，1 进行中，2 已结束
#define GAME_TIME_VAR          0x2001U    // 当前游戏时间(ms)
#define SCORE_VAR              0x2002U    // 得分显示
#define JUDGE_RESULT_VAR       0x2003U    // 判定结果显示
#define PAGE_CONVERT_5_VAR     0x2004U    // 页面5底层转换变量
#define PAGE_CONVERT_8_VAR     0x2005U    // 页面8底层转换变量
#define NOTE_Y_VAR_BASE        0x2006U    // 四个轨道Y坐标起始地址
#define HIT_BTN_VAR_BASE       0x200AU    // 四个判定按钮地址起始
#define AUDIO_CTRL_VAR         0x200EU    // 音频控制变量

#define TRACK_COUNT            4U
#define NOTE_COUNT             15U
#define SUCCESS_THRESHOLD      60U

#define NOTE_START_Y           20U
#define NOTE_END_Y             220U
#define NOTE_HIT_MIN_Y         200U
#define NOTE_HIT_MAX_Y         235U
#define NOTE_HIDDEN_Y          0U
#define NOTE_SPEED_INTERVAL    10U

#define GAME_STATUS_IDLE       0U
#define GAME_STATUS_PLAYING    1U
#define GAME_STATUS_ENDED      2U

static unsigned int game_timer = 0U;
static unsigned long total_score = 0UL;
static unsigned int hit_count = 0U;
static unsigned char current_game_page = PAGE_GAME_5;

static unsigned int note_start_time[TRACK_COUNT][NOTE_COUNT];
static unsigned char note_state[TRACK_COUNT][NOTE_COUNT];
static unsigned int note_y[TRACK_COUNT];

void Write_DGUS_Data(unsigned int addr, unsigned int data);
unsigned int Read_DGUS_Data(unsigned int addr);
void DGUS_PlayMusic(unsigned char track);
void DGUS_StopMusic(void);
void DGUS_JumpPage(unsigned char page);
void Delay_MS(unsigned int ms);

static unsigned int Get_Note_Y_Addr(unsigned char track)
{
    return NOTE_Y_VAR_BASE + (unsigned int)track;
}

static unsigned int Get_Hit_Btn_Addr(unsigned char track)
{
    return HIT_BTN_VAR_BASE + (unsigned int)track;
}

static unsigned int Get_Page_Convert_Addr(unsigned char page)
{
    return (page == PAGE_GAME_5) ? PAGE_CONVERT_5_VAR : PAGE_CONVERT_8_VAR;
}

static void Reset_Convert_Vars(void)
{
    Write_DGUS_Data(PAGE_CONVERT_5_VAR, 0U);
    Write_DGUS_Data(PAGE_CONVERT_8_VAR, 0U);
}

static void Reset_Notes(void)
{
    unsigned char i, j;
    for (i = 0; i < TRACK_COUNT; i++)
    {
        note_y[i] = NOTE_HIDDEN_Y;
        Write_DGUS_Data(Get_Note_Y_Addr(i), NOTE_HIDDEN_Y);
        for (j = 0; j < NOTE_COUNT; j++)
        {
            note_state[i][j] = 0U;
            note_start_time[i][j] = 0U;
        }
    }
}

static void Build_Note_Schedule(void)
{
    unsigned char track, note;
    unsigned int base_offset;
    unsigned int interval = MUSIC_LEN / NOTE_COUNT;

    for (track = 0; track < TRACK_COUNT; track++)
    {
        base_offset = track * 180U;
        for (note = 0; note < NOTE_COUNT; note++)
        {
            unsigned int start = 500U + note * interval + base_offset + (note % 3U) * 90U;
            if (start > MUSIC_LEN - 2000U)
            {
                start = MUSIC_LEN - 2000U - (NOTE_COUNT - note) * 80U;
            }
            note_start_time[track][note] = start;
            note_state[track][note] = 0U;
        }
    }
}

static void Update_Note_Positions(void)
{
    unsigned char track, note;
    for (track = 0; track < TRACK_COUNT; track++)
    {
        unsigned char active_found = 0U;
        for (note = 0; note < NOTE_COUNT; note++)
        {
            if (note_state[track][note] == 0U && game_timer >= note_start_time[track][note])
            {
                note_state[track][note] = 1U;
            }
            if (note_state[track][note] == 1U)
            {
                unsigned int elapsed = game_timer - note_start_time[track][note];
                unsigned int y = NOTE_START_Y + elapsed / NOTE_SPEED_INTERVAL;
                if (y >= NOTE_END_Y)
                {
                    note_state[track][note] = 2U;
                    note_y[track] = NOTE_HIDDEN_Y;
                }
                else
                {
                    note_y[track] = y;
                }
                Write_DGUS_Data(Get_Note_Y_Addr(track), note_y[track]);
                active_found = 1U;
                break;
            }
        }
        if (!active_found)
        {
            Write_DGUS_Data(Get_Note_Y_Addr(track), NOTE_HIDDEN_Y);
        }
    }
}

static void Reset_Hit_Buttons(void)
{
    unsigned char track;
    for (track = 0; track < TRACK_COUNT; track++)
    {
        Write_DGUS_Data(Get_Hit_Btn_Addr(track), 0U);
    }
}

static void Check_Hit_Buttons(void)
{
    unsigned char track, note;
    for (track = 0; track < TRACK_COUNT; track++)
    {
        unsigned int btn = Read_DGUS_Data(Get_Hit_Btn_Addr(track));
        if (btn == 0U)
        {
            continue;
        }
        unsigned char hit = 0U;
        for (note = 0; note < NOTE_COUNT; note++)
        {
            if (note_state[track][note] == 1U)
            {
                if (note_y[track] >= NOTE_HIT_MIN_Y && note_y[track] <= NOTE_HIT_MAX_Y)
                {
                    hit = 1U;
                    hit_count++;
                    total_score += 100UL;
                    note_state[track][note] = 2U;
                    note_y[track] = NOTE_HIDDEN_Y;
                    Write_DGUS_Data(Get_Note_Y_Addr(track), NOTE_HIDDEN_Y);
                    Write_DGUS_Data(JUDGE_RESULT_VAR, 1U);
                }
                else
                {
                    Write_DGUS_Data(JUDGE_RESULT_VAR, 3U);
                }
                break;
            }
        }
        if (hit == 0U)
        {
            Write_DGUS_Data(JUDGE_RESULT_VAR, 3U);
        }
        Write_DGUS_Data(SCORE_VAR, total_score);
        Write_DGUS_Data(Get_Hit_Btn_Addr(track), 0U);
    }
}

static unsigned char Game_Success(void)
{
    unsigned int total_notes = TRACK_COUNT * NOTE_COUNT;
    unsigned int percent = (hit_count * 100U) / total_notes;
    return (percent >= SUCCESS_THRESHOLD) ? 1U : 0U;
}

static void End_Game(void)
{
    unsigned char success = Game_Success();
    unsigned char convert = success ? 1U : 2U;
    unsigned char target_page = PAGE_FAIL_7;

    Write_DGUS_Data(Get_Page_Convert_Addr(current_game_page), convert);
    Write_DGUS_Data(GAME_STATUS_VAR, GAME_STATUS_ENDED);

    if (current_game_page == PAGE_GAME_5)
    {
        target_page = success ? PAGE_SUCCESS_6 : PAGE_FAIL_7;
    }
    else
    {
        target_page = success ? PAGE_SUCCESS_9 : PAGE_FAIL_10;
    }

    DGUS_StopMusic();
    Delay_MS(200);
    DGUS_JumpPage(target_page);
}

void Game_UI_Init(unsigned char page)
{
    current_game_page = page;
    game_timer = 0U;
    total_score = 0UL;
    hit_count = 0U;

    Reset_Convert_Vars();
    Reset_Notes();
    Build_Note_Schedule();
    Reset_Hit_Buttons();

    Write_DGUS_Data(GAME_STATUS_VAR, GAME_STATUS_PLAYING);
    Write_DGUS_Data(GAME_TIME_VAR, 0U);
    Write_DGUS_Data(SCORE_VAR, 0U);
    Write_DGUS_Data(JUDGE_RESULT_VAR, 0U);
    Write_DGUS_Data(Get_Page_Convert_Addr(PAGE_GAME_5), 0U);
    Write_DGUS_Data(Get_Page_Convert_Addr(PAGE_GAME_8), 0U);

    DGUS_PlayMusic(1U);
}

void Game_MainLoop(void)
{
    unsigned int status = Read_DGUS_Data(GAME_STATUS_VAR);
    if (status == GAME_STATUS_PLAYING)
    {
        game_timer++;
        Write_DGUS_Data(GAME_TIME_VAR, game_timer);
        Update_Note_Positions();
        Check_Hit_Buttons();

        if (game_timer >= MUSIC_LEN)
        {
            End_Game();
        }
    }
}

void DGUS_PageChange_Callback(unsigned char now_page)
{
    if (now_page == PAGE_GAME_5 || now_page == PAGE_GAME_8)
    {
        Game_UI_Init(now_page);
    }
}

void main(void)
{
    sys_init();
    Reset_Convert_Vars();
    Delay_MS(10U);
    while (1)
    {
        Game_MainLoop();
        Delay_MS(1U);
    }
}

void Write_DGUS_Data(unsigned int addr, unsigned int data)
{
    unsigned char buf[2];
    buf[0] = (unsigned char)(data >> 8);
    buf[1] = (unsigned char)(data & 0xFF);
    sys_write_vp(addr, buf, 2);
}

unsigned int Read_DGUS_Data(unsigned int addr)
{
    unsigned char buf[2] = {0U};
    sys_read_vp(addr, buf, 2);
    return ((unsigned int)buf[0] << 8) | buf[1];
}

void DGUS_PlayMusic(unsigned char track)
{
    if (track == 1U)
    {
        Write_DGUS_Data(AUDIO_CTRL_VAR, 1U);
    }
    else if (track == 2U)
    {
        Write_DGUS_Data(AUDIO_CTRL_VAR, 2U);
    }
}

void DGUS_StopMusic(void)
{
    Write_DGUS_Data(AUDIO_CTRL_VAR, 0U);
}

void DGUS_JumpPage(unsigned char page)
{
    unsigned char buf[1] = { page };
    sys_write_vp(0x0084U, buf, 1);
}

void Delay_MS(unsigned int ms)
{
    sys_delay_ms(ms);
}
